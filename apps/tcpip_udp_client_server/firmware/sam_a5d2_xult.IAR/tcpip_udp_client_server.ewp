# IAR project tcpip_udp_client_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: __SAMA5D2__; __PIC32C__
  ICCARM.CCDiagSuppress: Pe186,Pe188
  ICCARM.CCIncludePath2: ..\src\config\sam_a5d2_xult\library; ..\src\config\sam_a5d2_xult\library\tcpip\src; ..\src\config\sam_a5d2_xult\library\tcpip\src\common; ..\src; ..\src\config\sam_a5d2_xult; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS; ..\..\firmware\src\config\sam_a5d2_xult\library; ..\..\firmware\src\config\sam_a5d2_xult\library\tcpip\src; ..\..\firmware\src\config\sam_a5d2_xult\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\firmware\src\config\sam_a5d2_xult\library; ..\..\firmware\src\config\sam_a5d2_xult\library\tcpip\src; ..\..\firmware\src\config\sam_a5d2_xult\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: tcpip_udp_client_server.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: app_commands.c app_commands.h
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_a5d2_xult
    ../src/config/sam_a5d2_xult/: device.h system_config.h system_definitions.h user.h configuration.h device_cache.h toolchain_specifics.h definitions.h interrupts.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/tc
    ../src/config/sam_a5d2_xult/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/uart
    ../src/config/sam_a5d2_xult/peripheral/uart/: plib_uart_common.h plib_uart1.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/mmu
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/matrix
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/clk
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/pio
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/aic
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system
    ../src/config/sam_a5d2_xult/system/: sys_time_h2_adapter.h sys_random_h2_adapter.h system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/time
    ../src/config/sam_a5d2_xult/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/int
    ../src/config/sam_a5d2_xult/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/reset
    ../src/config/sam_a5d2_xult/system/reset/: sys_reset.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/debug
    ../src/config/sam_a5d2_xult/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/command
    ../src/config/sam_a5d2_xult/system/command/: sys_command.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/console
    ../src/config/sam_a5d2_xult/system/console/: sys_console.h
  group Harmony3/Header Files/config/sam_a5d2_xult/bsp
    ../src/config/sam_a5d2_xult/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_a5d2_xult/library/tcpip
    ../src/config/sam_a5d2_xult/library/tcpip/: tcpip_common_ports.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_heap.h tcpip_helpers.h ndp.h ipv4.h ipv6.h icmpv6.h dhcpv6.h arp.h udp.h tcp.h berkeley_api.h dhcp.h dhcps.h dhcp_server.h zero_conf_link_local.h zero_conf_multicast_dns.h dns.h dnss.h ftp.h ftpc.h icmp.h nbns.h ddns.h telnet.h smtp.h sntp.h http.h http_net.h snmp.h snmpv3.h tcpip_announce.h lldp.h smtpc.h igmp.h tftpc.h tftps.h tcpip_reboot.h iperf.h tcpip_commands.h tcpip.h tcpip_mac_bridge.h tcpip_ethernet.h
  group Harmony3/Header Files/config/sam_a5d2_xult/library/tcpip/src
    ../src/config/sam_a5d2_xult/library/tcpip/src/: tcpip_heap_alloc.h ndp_manager.h ndp_private.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h icmp_manager.h icmpv6_manager.h arp_manager.h arp_private.h udp_manager.h udp_private.h tcp_manager.h tcp_private.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcp_server_manager.h dhcp_server_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h nbns_manager.h ddns_manager.h telnet_manager.h smtp_manager.h sntp_manager.h http_manager.h http_private.h http_net_manager.h http_net_private.h snmp_manager.h snmp_private.h snmpv3_private.h tcpip_announce_manager.h smtpc_manager.h smtpc_private.h igmp_manager.h igmp_private.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h tcpip_reboot_manager.h iperf_manager.h tcpip_commands_manager.h hash_fnv.h link_list.h oahash.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_types.h berkeley_manager.h dhcpv6_manager.h dhcpv6_private.h lldp_manager.h lldp_private.h lldp_tlv.h tcpip_mac_bridge_manager.h tcpip_mac_bridge_private.h
  group Harmony3/Header Files/config/sam_a5d2_xult/library/tcpip/src/common
    ../src/config/sam_a5d2_xult/library/tcpip/src/common/: helpers.h sys_fs_shell.h
  group Harmony3/Header Files/config/sam_a5d2_xult/net_pres/pres
    ../src/config/sam_a5d2_xult/net_pres/pres/: net_pres.h net_pres_socketapi.h net_pres_socketapiconversion.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver
    ../src/config/sam_a5d2_xult/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/gmac
    ../src/config/sam_a5d2_xult/driver/gmac/: drv_gmac.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/gmac/src
    ../src/config/sam_a5d2_xult/driver/gmac/src/: drv_gmac_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/gmac/src/dynamic
    ../src/config/sam_a5d2_xult/driver/gmac/src/dynamic/: _gmac_dcpt_lists.h drv_gmac_lib.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/miim
    ../src/config/sam_a5d2_xult/driver/miim/: drv_miim.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/miim/src
    ../src/config/sam_a5d2_xult/driver/miim/src/: drv_miim_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/miim/src/dynamic
    ../src/config/sam_a5d2_xult/driver/miim/src/dynamic/: drv_miim_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/ethphy
    ../src/config/sam_a5d2_xult/driver/ethphy/: drv_ethphy.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/ethphy/src
    ../src/config/sam_a5d2_xult/driver/ethphy/src/: drv_ethphy_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/ethphy/src/dynamic
    ../src/config/sam_a5d2_xult/driver/ethphy/src/dynamic/: drv_extphy_regs.h drv_extphy_ksz8081.h
  group Harmony3/Header Files/config/sam_a5d2_xult/osal
    ../src/config/sam_a5d2_xult/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: sama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/instance
    ../src/packs/ATSAMA5D27_DFP/instance/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h gmac.h i2sc0.h i2sc1.h icm.h isc.h l2cc.h lcdc.h matrix0.h matrix1.h mcan0.h mcan1.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi0.h qspi1.h rstc.h rtc.h rxlp.h saic.h sckc.h sdmmc0.h sdmmc1.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi0.h spi1.h ssc0.h ssc1.h tc0.h tc1.h tdes.h trng.h twihs0.h twihs1.h uart0.h uart1.h uart2.h uart3.h uart4.h udphs.h wdt.h xdmac0.h xdmac1.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_cp15.h core_ca.h
  group Harmony3/Source Files
    ../src/: app.c main.c
  group Harmony3/Source Files/config/sam_a5d2_xult
    ../src/config/sam_a5d2_xult/: tasks.c initialization.c interrupts.c cstartup.s fault_handlers.c
  group Harmony3/Source Files/config/sam_a5d2_xult/library/tcpip/src
    ../src/config/sam_a5d2_xult/library/tcpip/src/: icmp.c nbns.c arp.c tcpip_commands.c ipv4.c tcpip_heap_alloc.c tcpip_heap_internal.c dhcp.c dns.c hash_fnv.c oahash.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c tcpip_announce.c udp.c
  group Harmony3/Source Files/config/sam_a5d2_xult/library/tcpip/src/common
    ../src/config/sam_a5d2_xult/library/tcpip/src/: helpers.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/tc
    ../src/config/sam_a5d2_xult/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/uart
    ../src/config/sam_a5d2_xult/peripheral/uart/: plib_uart1.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/mmu
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/matrix
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/clk
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/pio
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/aic
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system
    ../src/config/sam_a5d2_xult/system/: sys_time_h2_adapter.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/time
    ../src/config/sam_a5d2_xult/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/console
    ../src/config/sam_a5d2_xult/system/console/src/: sys_console_uart.h sys_console_uart_definitions.h sys_console_uart.c sys_console.c sys_console_local.h
  group Harmony3/Source Files/config/sam_a5d2_xult/system/int
    ../src/config/sam_a5d2_xult/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/reset
    ../src/config/sam_a5d2_xult/system/reset/: sys_reset.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/command
    ../src/config/sam_a5d2_xult/system/command/src/: sys_command.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/debug
    ../src/config/sam_a5d2_xult/system/debug/src/: sys_debug_local.h sys_debug.c
  group Harmony3/Source Files/config/sam_a5d2_xult/bsp
    ../src/config/sam_a5d2_xult/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_a5d2_xult/driver/gmac/src/dynamic
    ../src/config/sam_a5d2_xult/driver/gmac/src/dynamic/: drv_gmac.c drv_gmac_lib_samA5D2.c
  group Harmony3/Source Files/config/sam_a5d2_xult/driver/miim/src/dynamic
    ../src/config/sam_a5d2_xult/driver/miim/src/dynamic/: drv_miim.c
  group Harmony3/Source Files/config/sam_a5d2_xult/driver/ethphy/src/dynamic
    ../src/config/sam_a5d2_xult/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
  group Harmony3/Source Files/config/sam_a5d2_xult/stdio
    ../src/config/sam_a5d2_xult/stdio/: iar_monitor.c
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xult/: ddr.icf
