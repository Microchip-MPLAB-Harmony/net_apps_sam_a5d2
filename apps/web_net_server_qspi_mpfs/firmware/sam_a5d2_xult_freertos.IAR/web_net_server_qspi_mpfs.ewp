# IAR project web_net_server_qspi_mpfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; __FPU_PRESENT=1; __SAMA5D2__; __PIC32C__
  ICCARM.CCDiagSuppress: Pe186,Pe188,Pa089,Pa039
  ICCARM.CCIncludePath2: ..\src\config\sam_a5d2_xult_freertos\library; ..\src\config\sam_a5d2_xult_freertos\library\tcpip\src; ..\src\config\sam_a5d2_xult_freertos\library\tcpip\src\common; ..\src; ..\src\config\sam_a5d2_xult_freertos; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS; ..\src\third_party\wolfssl; ..\src\third_party\wolfssl\wolfssl; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\src\third_party\rtos\FreeRTOS\Source\include; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\src\config\sam_a5d2_xult_freertos; .
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xult_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult_freertos\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; __FPU_PRESENT=1; __SAMA5D2__; __PIC32C__; NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: rawWrite.c
  group Harmony3/Header Files
    ../src/: app.h http_net_print.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos
    ../src/config/sam_a5d2_xult_freertos/: user.h configuration.h device.h system_config.h system_definitions.h device_cache.h toolchain_specifics.h definitions.h config.h FreeRTOSConfig.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver
    ../src/config/sam_a5d2_xult_freertos/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/memory
    ../src/config/sam_a5d2_xult_freertos/driver/memory/src/: drv_memory_local.h
    ../src/config/sam_a5d2_xult_freertos/driver/memory/: drv_memory.h drv_memory_definitions.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/mx25l
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/: drv_mx25l.h drv_mx25l_definitions.h
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/src/: drv_mx25l_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/miim
    ../src/config/sam_a5d2_xult_freertos/driver/miim/: drv_miim.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/miim/src
    ../src/config/sam_a5d2_xult_freertos/driver/miim/src/: drv_miim_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/miim/src/dynamic
    ../src/config/sam_a5d2_xult_freertos/driver/miim/src/dynamic/: drv_miim_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/gmac
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/: drv_gmac.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/gmac/src
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/src/: drv_gmac_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/gmac/src/dynamic
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/src/dynamic/: _gmac_dcpt_lists.h drv_gmac_lib.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/ethphy
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/: drv_ethphy.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/ethphy/src
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/src/: drv_ethphy_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/driver/ethphy/src/dynamic
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/src/dynamic/: drv_extphy_regs.h drv_extphy_ksz8081.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system
    ../src/config/sam_a5d2_xult_freertos/system/: system.h system_common.h system_module.h system_media.h sys_time_h2_adapter.h sys_random_h2_adapter.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/time
    ../src/config/sam_a5d2_xult_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult_freertos/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/int
    ../src/config/sam_a5d2_xult_freertos/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/cache
    ../src/config/sam_a5d2_xult_freertos/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/debug
    ../src/config/sam_a5d2_xult_freertos/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/fs
    ../src/config/sam_a5d2_xult_freertos/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/fs/mpfs
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/: mpfs.h mpfs_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/command
    ../src/config/sam_a5d2_xult_freertos/system/command/: sys_command.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/system/console
    ../src/config/sam_a5d2_xult_freertos/system/console/: sys_console.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/osal
    ../src/config/sam_a5d2_xult_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/net_pres/pres
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/: net_pres.h net_pres_certstore.h net_pres_encryptionproviderapi.h net_pres_socketapi.h net_pres_transportapi.h net_pres_socketapiconversion.h net_pres_enc_glue.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/net_pres/pres/src
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/src/: net_pres_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/pit
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/tc
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/uart
    ../src/config/sam_a5d2_xult_freertos/peripheral/uart/: plib_uart_common.h plib_uart1.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/mmu
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/matrix
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/clk
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/pio
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/aic
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/peripheral/qspi
    ../src/config/sam_a5d2_xult_freertos/peripheral/qspi/: plib_qspi_common.h plib_qspi0.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/bsp
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/library/tcpip
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/: tcpip_common_ports.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_heap.h tcpip_helpers.h ndp.h ipv4.h ipv6.h icmpv6.h dhcpv6.h arp.h udp.h tcp.h berkeley_api.h dhcp.h dhcps.h zero_conf_link_local.h zero_conf_multicast_dns.h dns.h dnss.h ftp.h ftpc.h icmp.h nbns.h ddns.h telnet.h smtp.h sntp.h http.h http_net.h snmp.h snmpv3.h tcpip_announce.h lldp.h smtpc.h igmp.h tftpc.h tftps.h tcpip_reboot.h iperf.h tcpip_commands.h tcpip.h tcpip_mac_bridge.h tcpip_ethernet.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/library/tcpip/src
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/: tcpip_heap_alloc.h ndp_manager.h ndp_private.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h icmp_manager.h icmpv6_manager.h arp_manager.h arp_private.h udp_manager.h udp_private.h tcp_manager.h tcp_private.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h nbns_manager.h ddns_manager.h telnet_manager.h smtp_manager.h sntp_manager.h http_manager.h http_private.h http_net_manager.h http_net_private.h snmp_manager.h snmp_private.h snmpv3_private.h tcpip_announce_manager.h smtpc_manager.h smtpc_private.h igmp_manager.h igmp_private.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h tcpip_reboot_manager.h iperf_manager.h tcpip_commands_manager.h hash_fnv.h link_list.h oahash.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_types.h berkeley_manager.h dhcpv6_manager.h dhcpv6_private.h lldp_manager.h lldp_private.h lldp_tlv.h tcpip_mac_bridge_manager.h tcpip_mac_bridge_private.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/library/tcpip/src/common
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/common/: helpers.h sys_fs_shell.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos/crypto
    ../src/config/sam_a5d2_xult_freertos/crypto/: crypto.h
  group Harmony3/Header Files/wolfssl
    ../src/third_party/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h sniffer.h sniffer_error.h ssl.h test.h version.h wolfio.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_cp15.h core_ca.h
  group Harmony3/Header Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/: arc4.h asn.h asn_public.h blake2-impl.h blake2-int.h blake2.h camellia.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h cpuid.h cryptocb.h curve25519.h curve448.h des3.h dh.h dsa.h ecc.h ed25519.h ed448.h error-crypt.h fe_448.h fe_operations.h fips_test.h ge_448.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h memory.h mem_track.h misc.h mpi_class.h mpi_superclass.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h selftest.h sha3.h signature.h sp.h sp_int.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_pkcs11.h wolfevent.h wolfmath.h settings.h aes.h sha.h sha256.h sha512.h wc_port.h
  group Harmony3/Header Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/port/pic32/: pic32mz-crypt.h CryptoLib_cf_pb.h CryptoLib_ClearFlags_pb.h CryptoLib_Comp_pb.h CryptoLib_CondCopy_pb.h CryptoLib_CRT_pb.h CryptoLib_Div_pb.h CryptoLib_ExpMod_pb.h CryptoLib_FastCopy_pb.h CryptoLib_Fill_pb.h CryptoLib_Fmult_pb.h CryptoLib_GCD_pb.h CryptoLib_GF2NEccAdd_pb.h CryptoLib_GF2NEccConv_pb.h CryptoLib_GF2NEccDbl_pb.h CryptoLib_GF2NEccMul_pb.h CryptoLib_GF2NEcDsa_pb.h CryptoLib_Hardware_pb.h CryptoLib_Headers_pb.h CryptoLib_JumpTable_pb.h CryptoLib_mapping_pb.h CryptoLib_PrimeGen_pb.h CryptoLib_Rc_pb.h CryptoLib_RedMod_pb.h CryptoLib_Rng_pb.h CryptoLib_SelfTest_pb.h CryptoLib_Services_pb.h CryptoLib_Smult_pb.h CryptoLib_Square_pb.h CryptoLib_Swap_pb.h CryptoLib_typedef_pb.h CryptoLib_ZpEccAddSub_pb.h CryptoLib_ZpEccAdd_pb.h CryptoLib_ZpEccConv_pb.h CryptoLib_ZpEccDbl_pb.h CryptoLib_ZpEccMul_pb.h CryptoLib_ZpEccQuickDualMul_pb.h CryptoLib_ZpEcDsa_pb.h crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_crya_saml11.h crypt_ecc_ba414e.h crypt_ecc_pukcl.h crypt_pukcl_definitions.h crypt_pukcl_functions.h crypt_rng_hw.h crypt_rsa_pukcl.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h crypt_wolfcryptcb.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/CA5
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: portASM.h portmacro.h
  group Harmony3/Source Files
    ../src/: app.c http_net_print.c custom_http_net_app.c mpfs_net_img.c main.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos
    ../src/config/sam_a5d2_xult_freertos/: tasks.c initialization.c interrupts.c cstartup.s fault_handlers.c freertos_hooks.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/library/tcpip/src
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/: icmp.c tcp.c arp.c telnet.c iperf.c ipv4.c smtpc.c tcpip_announce.c udp.c http_net.c nbns.c tcpip_commands.c tcpip_heap_alloc.c tcpip_heap_internal.c dhcp.c dns.c hash_fnv.c oahash.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c sntp.c tftpc.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/library/tcpip/src/common
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/common/: sys_fs_shell.c
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/: helpers.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/driver/memory
    ../src/config/sam_a5d2_xult_freertos/driver/memory/src/: drv_memory.c drv_memory_file_system.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/driver/mx25l
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/src/: drv_mx25l.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/driver/miim/src/dynamic
    ../src/config/sam_a5d2_xult_freertos/driver/miim/src/dynamic/: drv_miim.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/driver/gmac/src/dynamic
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/src/dynamic/: drv_gmac.c drv_gmac_lib_samA5D2.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/driver/ethphy/src/dynamic
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system
    ../src/config/sam_a5d2_xult_freertos/system/: sys_time_h2_adapter.c sys_random_h2_adapter.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/time
    ../src/config/sam_a5d2_xult_freertos/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/console
    ../src/config/sam_a5d2_xult_freertos/system/console/src/: sys_console_uart.h sys_console_uart_definitions.h sys_console_uart.c sys_console.c sys_console_local.h
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/int
    ../src/config/sam_a5d2_xult_freertos/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/cache
    ../src/config/sam_a5d2_xult_freertos/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/fs
    ../src/config/sam_a5d2_xult_freertos/system/fs/src/: sys_fs.c sys_fs_media_manager.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/fs/mpfs
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/: mpfs.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/command
    ../src/config/sam_a5d2_xult_freertos/system/command/src/: sys_command.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/system/debug
    ../src/config/sam_a5d2_xult_freertos/system/debug/src/: sys_debug_local.h sys_debug.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/osal
    ../src/config/sam_a5d2_xult_freertos/osal/: osal_freertos.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/net_pres/pres
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/: net_pres_enc_glue.c net_pres_cert_store.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/net_pres/pres/src
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/src/: net_pres.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/pit
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/tc
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/uart
    ../src/config/sam_a5d2_xult_freertos/peripheral/uart/: plib_uart1.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/mmu
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/matrix
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/clk
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/pio
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/aic
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/peripheral/qspi
    ../src/config/sam_a5d2_xult_freertos/peripheral/qspi/: plib_qspi0.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/bsp
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/stdio
    ../src/config/sam_a5d2_xult_freertos/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos/crypto
    ../src/config/sam_a5d2_xult_freertos/crypto/src/: crypto.c
  group Harmony3/Source Files/wolfssl
    ../src/third_party/wolfssl/src/: crl.c keys.c ocsp.c sniffer.c ssl.c tls.c tls13.c wolfio.c internal.c
  group Harmony3/Source Files/web_pages
    ../src/web_pages/: auth.htm cookies.htm dynvars.htm footer.htm forms.htm harmony.gif header.htm index.htm leds.cgi mchp.css mchp.gif mchp.js snmp.bib ssi.htm status.xml upload.htm
  group Harmony3/Source Files/web_pages/dyndns
    ../src/web_pages/dyndns/: index.htm
  group Harmony3/Source Files/web_pages/email
    ../src/web_pages/email/: index.htm
  group Harmony3/Source Files/web_pages/protect
    ../src/web_pages/protect/: config.htm index.htm reboot.cgi reboot.htm
  group Harmony3/Source Files/web_pages/snmp
    ../src/web_pages/snmp/: snmpconfig.htm
  group Harmony3/Source Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/: arc4.c asm.c asn.c blake2b.c blake2s.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c cryptocb.c curve25519.c curve448.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c ed448.c error.c fe_448.c fe_low_mem.c fe_operations.c ge_448.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c ripemd.c rsa.c sha3.c signature.c sp_arm32.c sp_arm64.c sp_armthumb.c sp_c32.c sp_c64.c sp_cortexm.c sp_dsp32.c sp_int.c sp_x86_64.c srp.c tfm.c wc_dsp.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c aes.c des3.c random.c sha.c sha256.c sha512.c
  group Harmony3/Source Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/port/pic32/: pic32mz-crypt.c crypt_aes_sam6149.c crypt_aes_u2238.c crypt_ecc_ba414e.c crypt_ecc_pukcl.c crypt_pukcl_functions.c crypt_rng_sam6334.c crypt_rng_u2242.c crypt_rsa_pukcl.c crypt_sam_u2803.c crypt_sha1_sam11105.c crypt_sha1_sam6156.c crypt_sha224_sam11105.c crypt_sha224_sam6156.c crypt_sha256_sam11105.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_tdes_sam6150.c crypt_wolfcryptcb.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_3.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/CA5
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: port.c portASM.s FreeRTOS_tick_config.c
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xult_freertos/: ddr.icf
